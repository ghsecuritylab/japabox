# Keil uVision project lwip_httpsrv_freertos.uvprojx, settings and files
target lwip_httpsrv_freertos Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, USE_RTOS=1, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F;../../../../../../../rtos/freertos_8.2.3/Source/include;;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/MK66F18/drivers;..;../../../../../../../devices/MK66F18/utilities;../../../../../../../middleware/lwip_1.4.1;../../../../../../../middleware/lwip_1.4.1/port;../../../../../../../middleware/lwip_1.4.1/port/arch;../../../../../../../middleware/lwip_1.4.1/src;../../../../../../../middleware/lwip_1.4.1/src/include;../../../../../../../middleware/lwip_1.4.1/src/include/ipv4;../../../../../../../middleware/lwip_1.4.1/src/include/ipv4/lwip;../../../../../../../middleware/lwip_1.4.1/src/include/ipv6;../../../../../../../middleware/lwip_1.4.1/src/include/ipv6/lwip;../../../../../../../middleware/lwip_1.4.1/src/include/lwip;../../../../../../../middleware/lwip_1.4.1/src/include/netif;../../../../../../../middleware/lwip_1.4.1/src/include/posix;../../../../../../../middleware/lwip_1.4.1/src/include;../../../../../../../rtos/freertos_8.2.3/Source;../../../../..;../../../../../../../devices/MK66F18
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
    ../../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group freertos:portable
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group doc
    ../: readme.txt
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../../devices/MK66F18/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group lwip-port
    ../../../../../../../middleware/lwip_1.4.1/port/arch/: cc.h perf.h
    ../../../../../../../middleware/lwip_1.4.1/port/: ethernetif.c lwipopts.h sys_arch.c
    ../../../../../../../devices/MK66F18/drivers/: fsl_port.h
  group source
    ../: httpserver-netconn.h lwip_httpsrv_freertos.c FreeRTOSConfig.h
  group utilities
    ../../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lwip-src-api
    ../../../../../../../middleware/lwip_1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../middleware/lwip_1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../middleware/lwip_1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-src-core-snmp
    ../../../../../../../middleware/lwip_1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip-src-include-ipv4
    ../../../../../../../middleware/lwip_1.4.1/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip-src-include-lwip
    ../../../../../../../middleware/lwip_1.4.1/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip-src-include-netif
    ../../../../../../../middleware/lwip_1.4.1/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip-src-include-posix
    ../../../../../../../middleware/lwip_1.4.1/src/include/posix/: netdb.h
    ../../../../../../../middleware/lwip_1.4.1/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../middleware/lwip_1.4.1/src/netif/: etharp.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../middleware/lwip_1.4.1/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h ppp_md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group freertos
    ../../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
target lwip_httpsrv_freertos Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpsrv_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, USE_RTOS=1, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove 
--predefine="-D__ram_vector_table__=1"

# Keil uVision project pin_detect_hid_mouse_bm.uvprojx, settings and files
target pin_detect_hid_mouse_bm Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pin_detect_hid_mouse_bm.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK66FN2M0VMD18, USB_STACK_BM, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../devices/MK66F18/utilities;../../../../../../middleware/usb_1.0.0;../../../../../../middleware/usb_1.0.0/osa;../../../../../../middleware/usb_1.0.0/include;../../../../../../CMSIS/Include;../../../../../../middleware/usb_1.0.0/device;../../../..;../../../../../../middleware/usb_1.0.0/host;../../../../../../middleware/usb_1.0.0/phy;../../../../../../devices/MK66F18/drivers;../../../../../../middleware/usb_1.0.0/host/class;../../../../../../devices/MK66F18
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group usb-host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb-device-source-khci
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_khci.c usb_device_khci.h
  group usb-device-source-ehci
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_ehci.c usb_device_ehci.h
  group usb-phy
    ../../../../../../middleware/usb_1.0.0/phy/: usb_phy.c usb_phy.h
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_dci.c usb_device_dci.h
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-host-class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_hid.c usb_host_hid.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-hid
    ../: usb_device_hid.c usb_device_hid.h
  group sources
    ../: app.c device_mouse.c device_mouse.h host_mouse.c host_mouse.h usb_device_descriptor.c usb_device_descriptor.h usb_host_config.h usb_device_config.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group usb-device-include
    ../../../../../../middleware/usb_1.0.0/device/: usb_device.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target pin_detect_hid_mouse_bm Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pin_detect_hid_mouse_bm.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MK66FN2M0VMD18, USB_STACK_BM, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove

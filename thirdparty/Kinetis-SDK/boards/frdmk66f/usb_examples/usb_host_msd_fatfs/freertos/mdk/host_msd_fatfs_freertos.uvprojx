# Keil uVision project host_msd_fatfs_freertos.uvprojx, settings and files
target host_msd_fatfs_freertos Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK66FN2M0VMD18, USB_STACK_FREERTOS_HEAP_SIZE=32768, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F;../../../../../../rtos/freertos_8.2.3/Source/include;..;../../../../../../middleware/fatfs_0.11a/src;../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk;../../../../../../rtos/freertos_8.2.3/Source;../../../../../../devices/MK66F18/utilities;../../../../../../middleware/usb_1.0.0;../../../../../../middleware/usb_1.0.0/osa;../../../../../../middleware/usb_1.0.0/include;../../../../../../CMSIS/Include;../../../..;../../../../../../middleware/usb_1.0.0/host;../../../../../../middleware/usb_1.0.0/phy;../../../../../../devices/MK66F18/drivers;../../../../../../middleware/usb_1.0.0/host/class;../../../../../../devices/MK66F18
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove
  group freertos:portable
    ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group startup
    ../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group usb-host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host_ehci.c usb_host_ehci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb-phy
    ../../../../../../middleware/usb_1.0.0/phy/: usb_phy.c usb_phy.h
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group usb-host-class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group sources
    ../: app.c host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h FreeRTOSConfig.h
    ../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk/: fsl_usb_disk_freertos.c fsl_usb_disk.h
  group sources-fatfs
    ../../../../../../middleware/fatfs_0.11a/src/: diskio.c diskio.h ff.c ff.h
    ../../../../../../middleware/fatfs_0.11a/src/option/: unicode.c
  group freertos
    ../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target host_msd_fatfs_freertos Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: host_msd_fatfs_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MK66FN2M0VMD18, USB_STACK_FREERTOS_HEAP_SIZE=32768, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove

# Keil uVision project sdcard_freertos.uvprojx, settings and files
target sdcard_freertos Debug (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK66FN2M0VMD18, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F;../../../../../../rtos/freertos_8.2.3/Source/include;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MK66F18/drivers;..;../../../../../../devices/MK66F18/utilities;../../../../../../rtos/freertos_8.2.3/Source;../../../../../../middleware/sdmmc_2.0.0/inc;../../../../../../middleware/sdmmc_2.0.0/src;../../../..;../../../../../../devices/MK66F18
  asm define: CPU_MK66FN2M0VMD18, DEBUG,__CC_ARM,KEIL,FRDM_K66F180M, FREEDOM
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK66F18/arm/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group freertos:portable
    ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: sdcard_freertos.c event.h event.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group freertos
    ../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group sdmmc-src
    ../../../../../../middleware/sdmmc_2.0.0/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc-inc
    ../../../../../../middleware/sdmmc_2.0.0/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h
target sdcard_freertos Release (ARM-ADS)
  device: MK66FN2M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdcard_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK66FN2M0VMD18, FSL_RTOS_FREE_RTOS, FRDM_K66F, FREEDOM
  c misc: as above
  c include: as above
  asm define: CPU_MK66FN2M0VMI18, NDEBUG,__CC_ARM,KEIL,FRDM_K66F, FREEDOM
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove

# IAR project sdcard_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; FSL_RTOS_FREE_RTOS; FRDM_K66F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK66F18/drivers; ..; ../../../../../../devices/MK66F18/utilities; ../../../../../../rtos/freertos_8.2.3/Source; ../../../../../../middleware/sdmmc_2.0.0/inc; ../../../../../../middleware/sdmmc_2.0.0/src; ../../../..; ../../../../../../devices/MK66F18
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: sdcard_freertos.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; FSL_RTOS_FREE_RTOS; FRDM_K66F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group freertos
    ../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sdhc.h fsl_sdhc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: sdcard_freertos.c event.h event.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdmmc/src
    ../../../../../../middleware/sdmmc_2.0.0/src/: fsl_sd.c fsl_mmc.c fsl_sdmmc.c
  group sdmmc/inc
    ../../../../../../middleware/sdmmc_2.0.0/inc/: fsl_card.h fsl_specification.h fsl_sdmmc.h

# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; FRDM_K66F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK66F18/drivers; ..; ../../../../../../devices/MK66F18/utilities; ../../../..; ../../../../../../devices/MK66F18
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; ENET_ENHANCEDBUFFERDESCRIPTOR_MODE; FRDM_K66F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK66F18/iar/: startup_MK66F18.s
    ../../../../../../devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group doc
    ../: readme.txt
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../devices/MK66F18/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group utilities
    ../../../../../../devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
